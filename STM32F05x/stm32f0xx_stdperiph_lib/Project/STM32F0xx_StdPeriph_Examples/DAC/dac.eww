<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DAC_ADC\DAC_ADC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DAC_SignalsGeneration\DAC_SignalsGeneration.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>DAC_SignalsGeneration</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
      <member>
        <project>DAC_ADC</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


