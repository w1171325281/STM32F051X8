<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\WWDG_Example\WWDG_Example.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>WWDG_Example</project>
        <configuration>STM320518-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


